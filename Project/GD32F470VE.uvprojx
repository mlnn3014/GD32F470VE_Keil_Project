# Keil uVision project GD32F470VE.uvprojx, settings and files
target GD32F470VET6_Project (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\Core\Inc;..\App\Inc;..\Bsp\Inc;..\Compenents\bsp;..\Compenents\gd30ad3344;..\Compenents\oled;..\Compenents\oled\libdriver;..\Compenents\gd25qxx;..\Compenents\button;..\Compenents\sdio;..\Compenents\fatfs;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS_5\CMSIS\Core\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/Src/: adc_app.c btn_app.c led_app.c oled_app.c rtc_app.c scheduler.c sd_app.c usart_app.c
  group Core
    ../Core/Src/: main.c systick.c gd32f4xx_it.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Bsp
    ../Bsp/Src/: btn_bsp.c led_bsp.c oled_bsp.c
  group Components/bsp
    ../Compenents/bsp/: mcu_cmic_gd32f470vet6.c
  group Components/gd25qxx
    ../Compenents/gd25qxx/: gd25qxx.c lfs.c lfs_port.c lfs_util.c
  group Components/gd30ad3344
    ../Compenents/gd30ad3344/: gd30ad3344.c
  group Components/oled
    ../Compenents/oled/: oled.c
    ../Compenents/oled/libdriver/: driver_ssd1306.c
  group Components/button
    ../Compenents/button/: button.c
  group Components/sdio
    ../Compenents/sdio/: sdio_sdcard.c
  group Components/fatfs
    ../Compenents/fatfs/: diskio.c ff.c
    ../Compenents/fatfs/option/: ccsbcs.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
software components: CMSIS:CORE 6.1.0
